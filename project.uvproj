# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\AppBin.bat
  c flags: Optim=4 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .;..\..\..\rt-thread\components\dfs;..\..\..\rt-thread\components\dfs\filesystems\devfs;..\..\..\rt-thread\components\dfs\filesystems\uffs;..\..\..\rt-thread\components\dfs\filesystems\uffs\src\inc;..\..\..\rt-thread\components\dfs\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\usb\usbdevice;..\..\..\rt-thread\components\drivers\usb\usbhost;..\..\..\rt-thread\components\drivers\usb\usbhost\class;..\..\..\rt-thread\components\drivers\usb\usbhost\core;..\..\..\rt-thread\components\drivers\usb\usbhost\include;..\..\..\rt-thread\components\finsh;..\..\..\rt-thread\components\init;..\..\..\rt-thread\include;..\..\..\rt-thread\libcpu\arm\common;..\..\..\rt-thread\libcpu\arm\cortex-m4;..\..\STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F4xx_Libraries\CMSIS\Include;..\..\STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;..\..\STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32F4xx_Libraries\STM32_USB_Device_Library\Class\cdc\inc;..\..\STM32F4xx_Libraries\STM32_USB_Device_Library\Core\inc;..\..\STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;..\..\STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;..\..\drivers;applications;.\applications\FreeModbus\include;.\applications\FreeModbus\modbus\rtu;.\applications\FreeModbus\port;.\applications\FreeModbus\modbus\functions
  memory RVCT4: ROM 0x8020000 size 0xa0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x68000000 size 0x100000
  link misc: --inline .\mic\Debug.lib  .\mic\IconvData.lib  --remove .\mic\sstream.L
  group Applications
    ./applications/: main.c Setting.c SignalOut.c App.c stm32f4xx_flash.c UserApp.c Display.c
    ./mic/: SystemCommon.lib UserApp.lib
